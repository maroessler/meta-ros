# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "segmentation"
AUTHOR = "Abraham Monrroy <abrahammonrroy@yahoo.com>"
ROS_AUTHOR = "Tony Zhang <tony.zhang@robosense.cn>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=01c2bc31767ccb3a68e12f02612b2a97"

ROS_CN = "robosense"
ROS_BPN = "rslidar_driver"

ROS_BUILD_DEPENDS = " \
    libpcap \
    pcl \
    ros1-angles \
    ros1-diagnostic-updater \
    ros1-dynamic-reconfigure \
    ros1-message-generation \
    ros1-nodelet \
    ros1-pcl-conversions \
    ros1-pcl-ros \
    ros1-pluginlib \
    ros1-roscpp \
    ros1-roslaunch \
    ros1-roslib \
    ros1-rospy \
    ros1-rostest \
    ros1-rslidar-msgs \
    ros1-sensor-msgs \
    ros1-std-msgs \
    ros1-tf \
    ros1-tf2-ros \
"

ROS_BUILDTOOL_DEPENDS = " \
    ros1-catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    pcl \
    ros1-angles \
    ros1-diagnostic-updater \
    ros1-dynamic-reconfigure \
    ros1-message-runtime \
    ros1-nodelet \
    ros1-pcl-conversions \
    ros1-pcl-ros \
    ros1-pluginlib \
    ros1-roscpp \
    ros1-roslib \
    ros1-rospy \
    ros1-rslidar-msgs \
    ros1-sensor-msgs \
    ros1-std-msgs \
    ros1-tf \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    pcl \
    ros1-angles \
    ros1-diagnostic-updater \
    ros1-dynamic-reconfigure \
    ros1-message-runtime \
    ros1-nodelet \
    ros1-pcl-conversions \
    ros1-pcl-ros \
    ros1-pluginlib \
    ros1-roscpp \
    ros1-roslib \
    ros1-rospy \
    ros1-rslidar-msgs \
    ros1-sensor-msgs \
    ros1-std-msgs \
    ros1-tf \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/CPFL/robosense-release/archive/release/melodic/rslidar_driver/1.0.2-0.tar.gz
ROS_BRANCH ?= "branch=release/melodic/rslidar_driver"
SRC_URI = "git://github.com/CPFL/robosense-release;${ROS_BRANCH};protocol=https"
SRCREV = "403e948a17c8cba58a73f5b498387460072a668a"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}
