# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The pr2_mechanism_controllers package contains realtime     controllers that are meant for specific mechanisms of the PR2."
AUTHOR = "ROS Orphaned Package Maintainers <ros-orphaned-packages@googlegroups.com>"
ROS_AUTHOR = "Sachin Chita"
HOMEPAGE = "http://ros.org/pr2_mechanism_controllers"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "pr2_controllers"
ROS_BPN = "pr2_mechanism_controllers"

ROS_BUILD_DEPENDS = " \
    ros1-angles \
    ros1-control-toolbox \
    ros1-diagnostic-msgs \
    ros1-diagnostic-updater \
    ros1-filters \
    ros1-geometry-msgs \
    ros1-message-generation \
    ros1-nav-msgs \
    ros1-pluginlib \
    ros1-pr2-controller-interface \
    ros1-pr2-controllers-msgs \
    ros1-pr2-mechanism-model \
    ros1-pr2-mechanism-msgs \
    ros1-pr2-msgs \
    ros1-realtime-tools \
    ros1-robot-mechanism-controllers \
    ros1-rosconsole \
    ros1-roscpp \
    ros1-rospy \
    ros1-std-msgs \
    ros1-tf \
    ros1-visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ros1-catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ros1-angles \
    ros1-control-toolbox \
    ros1-diagnostic-msgs \
    ros1-diagnostic-updater \
    ros1-filters \
    ros1-geometry-msgs \
    ros1-message-runtime \
    ros1-nav-msgs \
    ros1-pluginlib \
    ros1-pr2-controller-interface \
    ros1-pr2-controllers-msgs \
    ros1-pr2-mechanism-model \
    ros1-pr2-mechanism-msgs \
    ros1-pr2-msgs \
    ros1-realtime-tools \
    ros1-robot-mechanism-controllers \
    ros1-rosconsole \
    ros1-roscpp \
    ros1-rospy \
    ros1-std-msgs \
    ros1-tf \
    ros1-visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ros1-angles \
    ros1-control-toolbox \
    ros1-diagnostic-msgs \
    ros1-diagnostic-updater \
    ros1-filters \
    ros1-geometry-msgs \
    ros1-message-runtime \
    ros1-nav-msgs \
    ros1-pluginlib \
    ros1-pr2-controller-interface \
    ros1-pr2-controllers-msgs \
    ros1-pr2-mechanism-model \
    ros1-pr2-mechanism-msgs \
    ros1-pr2-msgs \
    ros1-realtime-tools \
    ros1-robot-mechanism-controllers \
    ros1-rosconsole \
    ros1-roscpp \
    ros1-rospy \
    ros1-std-msgs \
    ros1-tf \
    ros1-visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/pr2-gbp/pr2_controllers-release/archive/release/melodic/pr2_mechanism_controllers/1.10.17-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/pr2_mechanism_controllers"
SRC_URI = "git://github.com/pr2-gbp/pr2_controllers-release;${ROS_BRANCH};protocol=https"
SRCREV = "95916a2b133b69b7fb48b463ab8ff6bc803b24fc"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}
