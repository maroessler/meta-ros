# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "The cob_object_detection_visualizer package visualizes the object detection result."
AUTHOR = "Richard Bormann <richard.bormann@ipa.fraunhofer.de>"
ROS_AUTHOR = "Richard Bormann <richard.bormann@ipa.fraunhofer.de>"
HOMEPAGE = "https://wiki.ros.org"
SECTION = "devel"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=3dce4ba60d7e51ec64f3c3dc18672dd3"

ROS_CN = "cob_perception_common"
ROS_BPN = "cob_object_detection_visualizer"

ROS_BUILD_DEPENDS = " \
    boost \
    opencv \
    pcl \
    ros1-cob-object-detection-msgs \
    ros1-cv-bridge \
    ros1-eigen-conversions \
    ros1-image-transport \
    ros1-message-filters \
    ros1-pcl-ros \
    ros1-roscpp \
    ros1-sensor-msgs \
    ros1-visualization-msgs \
"

ROS_BUILDTOOL_DEPENDS = " \
    ros1-catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    boost \
    opencv \
    pcl \
    ros1-cob-object-detection-msgs \
    ros1-cv-bridge \
    ros1-eigen-conversions \
    ros1-image-transport \
    ros1-message-filters \
    ros1-pcl-ros \
    ros1-roscpp \
    ros1-sensor-msgs \
    ros1-visualization-msgs \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    boost \
    opencv \
    pcl \
    ros1-cob-object-detection-msgs \
    ros1-cv-bridge \
    ros1-eigen-conversions \
    ros1-image-transport \
    ros1-message-filters \
    ros1-pcl-ros \
    ros1-roscpp \
    ros1-sensor-msgs \
    ros1-visualization-msgs \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ipa320/cob_perception_common-release/archive/release/melodic/cob_object_detection_visualizer/0.6.15-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/cob_object_detection_visualizer"
SRC_URI = "git://github.com/ipa320/cob_perception_common-release;${ROS_BRANCH};protocol=https"
SRCREV = "fa07237d540f17292c8c7c283b190432691fd0f9"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}
