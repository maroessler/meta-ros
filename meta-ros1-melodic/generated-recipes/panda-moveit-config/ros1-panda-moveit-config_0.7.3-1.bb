# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_melodic
inherit ros_superflore_generated

DESCRIPTION = "An automatically generated package with all the configuration and launch files for using the panda with the MoveIt! Motion Planning Framework"
AUTHOR = "Mike Lautman <mike@picknik.ai>"
ROS_AUTHOR = "Mike Lautman <mike@picknik.ai>"
HOMEPAGE = "http://moveit.ros.org/"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=10;endline=10;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "panda_moveit_config"
ROS_BPN = "panda_moveit_config"

ROS_BUILD_DEPENDS = " \
    ros1-franka-description \
"

ROS_BUILDTOOL_DEPENDS = " \
    ros1-catkin-native \
"

ROS_EXPORT_DEPENDS = " \
    ros1-franka-description \
    ros1-joint-state-publisher \
    ros1-moveit-fake-controller-manager \
    ros1-moveit-kinematics \
    ros1-moveit-planners-ompl \
    ros1-moveit-ros-move-group \
    ros1-moveit-ros-visualization \
    ros1-robot-state-publisher \
    ros1-topic-tools \
    ros1-xacro \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    ros1-franka-description \
    ros1-joint-state-publisher \
    ros1-moveit-fake-controller-manager \
    ros1-moveit-kinematics \
    ros1-moveit-planners-ompl \
    ros1-moveit-ros-move-group \
    ros1-moveit-ros-visualization \
    ros1-robot-state-publisher \
    ros1-topic-tools \
    ros1-xacro \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/ros-gbp/panda_moveit_config-release/archive/release/melodic/panda_moveit_config/0.7.3-1.tar.gz
ROS_BRANCH ?= "branch=release/melodic/panda_moveit_config"
SRC_URI = "git://github.com/ros-gbp/panda_moveit_config-release;${ROS_BRANCH};protocol=https"
SRCREV = "93fc82580913b1a25a7a2dc8f809782307681c79"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "catkin"

inherit ros_${ROS_BUILD_TYPE}
