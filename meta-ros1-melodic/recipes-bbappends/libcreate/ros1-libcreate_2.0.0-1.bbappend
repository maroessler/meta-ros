FILES_${PN} += " \
    ${ros_libdir}/cmake/${ROS_BPN}/ \
"