# Copyright (c) 2019 LG Electronics, Inc.

# Files/directories were installed but not shipped in any package:
#   /opt/ros/melodic/lib/libmoveit_pick_place_planner.so.1.0.2
#   /opt/ros/melodic/lib/libmoveit_move_group_pick_place_capability.so.1.0.2
inherit ros_insane_dev_so