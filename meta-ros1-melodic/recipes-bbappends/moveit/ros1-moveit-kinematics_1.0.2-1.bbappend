# ros1-moveit-kinematics: 5 installed and not shipped files. [installed-vs-shipped]
inherit ros_insane_dev_so