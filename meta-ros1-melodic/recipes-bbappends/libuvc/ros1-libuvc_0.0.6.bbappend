FILES_${PN}-dev += " \
    ${ros_libdir}/cmake/${ROS_BPN}/*.cmake \
"