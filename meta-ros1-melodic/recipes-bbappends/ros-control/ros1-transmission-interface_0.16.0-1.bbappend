ROS_EXEC_DEPENDS_append = " \
    ros1-class-loader \
"