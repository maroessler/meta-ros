DEPENDS_remove = " \
    ros1-find-object-2d \
    ros1-rviz \
"

RDEPENDS_${PN}_remove = " \
    ros1-find-object-2d \
    ros1-rviz \
"