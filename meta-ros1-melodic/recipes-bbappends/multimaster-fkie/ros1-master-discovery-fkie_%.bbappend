ROS_EXPORT_DEPENDS_remove = "avahi"
ROS_EXEC_DEPENDS_remove = "avahi"