# Copyright (c) 2020 LG Electronics, Inc.

# kobuki-ftdi is blacklisted
ROS_EXPORT_DEPENDS_remove = "ros1-kobuki-ftdi"
ROS_EXEC_DEPENDS_remove = "ros1-kobuki-ftdi"
