FILES_${PN} += " \
    ${ros_libdir}/${PYTHON_DIR}/dist-packages/vrpn.so \
"