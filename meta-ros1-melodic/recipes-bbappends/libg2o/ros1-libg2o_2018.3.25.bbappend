# mesa is recipe name, shouldn't be used in runtime dependencies
ROS_EXEC_DEPENDS_remove = "mesa"