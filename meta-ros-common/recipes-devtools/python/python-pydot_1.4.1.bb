require python-pydot.inc

inherit setuptools