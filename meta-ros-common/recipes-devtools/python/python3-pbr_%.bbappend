inherit update-alternatives

ALTERNATIVE_${PN} = " \
    pbr \
    "
ALTERNATIVE_PRIORITY = "5"