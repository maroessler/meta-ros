# Copyright (c) 2019 LG Electronics, Inc.

export STAGING_DIR_HOST
