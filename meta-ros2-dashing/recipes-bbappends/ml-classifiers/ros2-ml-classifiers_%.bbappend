# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    rclcpp \
"

ROS_BUILDTOOL_DEPENDS += " \
    ros2-rosidl-adapter-native \
    ros2-rosidl-default-generators-native \
"
