ROS_BUILDTOOL_DEPENDS += " \
    ros2-python-cmake-module-native \
    ros2-rosidl-adapter-native \
    ros2-rosidl-default-generators-native \
"