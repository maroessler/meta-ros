# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += "ros2-ros1-bridge"
