# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-ament-cmake-core-native \
    ros2-ament-package-native \
"
