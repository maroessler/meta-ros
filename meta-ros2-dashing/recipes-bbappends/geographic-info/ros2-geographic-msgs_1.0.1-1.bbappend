# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-python-cmake-module-native \
    python3-empy-native \
    python3-lark-parser-native \
    python3-numpy-native \
    ros2-rosidl-adapter-native \
    ros2-rosidl-generator-cpp-native \
    ros2-rosidl-generator-py-native \
    ros2-rosidl-parser-native \
    ros2-rosidl-typesupport-cpp-native \
"
