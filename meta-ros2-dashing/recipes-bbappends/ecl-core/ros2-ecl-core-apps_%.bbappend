CXXFLAGS += "-Wno-catch-value"
CXXFLAGS += "-Wno-unused-local-typedefs"
CXXFLAGS += "-Wno-deprecated"
