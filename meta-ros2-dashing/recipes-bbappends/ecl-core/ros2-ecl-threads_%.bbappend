# Copyright (c) 2019 LG Electronics, Inc.

inherit ros-insane

CXXFLAGS += "-Wno-unused-local-typedefs"
