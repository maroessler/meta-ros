# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-ament-package-native \
    python3-catkin-pkg-native \
"
