# Copyright (c) YEAR LG Electronics, Inc.

ROS_BUILD_DEPENDS_remove = "ros2-rosidl-typesupport-connext-c"
ROS_BUILD_DEPENDS_remove = "rosidl-typesupport-opensplice-c"
