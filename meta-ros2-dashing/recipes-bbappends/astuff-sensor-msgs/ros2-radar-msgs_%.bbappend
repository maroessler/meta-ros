# Copyright (c) 2020 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-python-cmake-module-native \
    ros2-rosidl-adapter-native \
    ros2-rosidl-generator-c-native \
    ros2-rosidl-generator-cpp-native \
    ros2-rosidl-generator-py-native \
    ros2-rosidl-parser-native \
    ros2-rosidl-typesupport-cpp-native \
    ros2-rosidl-typesupport-fastrtps-c-native \
    ros2-rosidl-typesupport-fastrtps-cpp-native \
    ros2-rosidl-typesupport-introspection-cpp-native \
"
