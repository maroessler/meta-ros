# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-rosidl-adapter-native \
    ros2-python-cmake-module-native \
    python3-numpy-native \
    ros2-rosidl-default-generators-native \
"
