# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILD_DEPENDS += " \
    ros2-fastcdr \
    ros2-fastrtps \
"
