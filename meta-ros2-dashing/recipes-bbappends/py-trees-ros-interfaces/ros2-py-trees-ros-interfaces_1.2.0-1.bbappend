# Copyright (c) 2019 LG Electronics, Inc.

ROS_BUILDTOOL_DEPENDS += " \
    ros2-rosidl-adapter-native \
    ros2-rosidl-parser-native \
    ros2-rosidl-default-generators-native \
    python3-empy-native \
    python3-numpy-native \
    python3-lark-parser-native \
"
