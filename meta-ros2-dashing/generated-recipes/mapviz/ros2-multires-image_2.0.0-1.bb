# Generated by superflore -- DO NOT EDIT
#
# Copyright Open Source Robotics Foundation

inherit ros_distro_dashing
inherit ros_superflore_generated

DESCRIPTION = "multires_image"
AUTHOR = "P. J. Reed <preed@swri.org>"
ROS_AUTHOR = "Marc Alban"
HOMEPAGE = "https://github.com/swri-robotics/mapviz"
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

ROS_CN = "mapviz"
ROS_BPN = "multires_image"

ROS_BUILD_DEPENDS = " \
    ${ROS_UNRESOLVED_PLATFORM_PKG_libqt5-opengl-dev} \
    qtbase \
    ros2-cv-bridge \
    ros2-geometry-msgs \
    ros2-gps-msgs \
    ros2-mapviz \
    ros2-pluginlib \
    ros2-rclcpp \
    ros2-swri-math-util \
    ros2-swri-transform-util \
    ros2-tf2 \
"

ROS_BUILDTOOL_DEPENDS = " \
    qtbase-native \
    ros2-ament-cmake-native \
"

ROS_EXPORT_DEPENDS = " \
    qtbase \
    ros2-cv-bridge \
    ros2-geometry-msgs \
    ros2-gps-msgs \
    ros2-mapviz \
    ros2-pluginlib \
    ros2-rclcpp \
    ros2-swri-math-util \
    ros2-swri-transform-util \
    ros2-tf2 \
"

ROS_BUILDTOOL_EXPORT_DEPENDS = ""

ROS_EXEC_DEPENDS = " \
    qtbase \
    ros2-cv-bridge \
    ros2-geometry-msgs \
    ros2-gps-msgs \
    ros2-mapviz \
    ros2-pluginlib \
    ros2-rclcpp \
    ros2-rclpy \
    ros2-swri-math-util \
    ros2-swri-transform-util \
    ros2-tf2 \
"

# Currently informational only -- see http://www.ros.org/reps/rep-0149.html#dependency-tags.
ROS_TEST_DEPENDS = ""

DEPENDS = "${ROS_BUILD_DEPENDS} ${ROS_BUILDTOOL_DEPENDS}"
# Bitbake doesn't support the "export" concept, so build them as if we needed them to build this package (even though we actually
# don't) so that they're guaranteed to have been staged should this package appear in another's DEPENDS.
DEPENDS += "${ROS_EXPORT_DEPENDS} ${ROS_BUILDTOOL_EXPORT_DEPENDS}"

RDEPENDS_${PN} += "${ROS_EXEC_DEPENDS}"

# matches with: https://github.com/swri-robotics-gbp/mapviz-release/archive/release/dashing/multires_image/2.0.0-1.tar.gz
ROS_BRANCH ?= "branch=release/dashing/multires_image"
SRC_URI = "git://github.com/swri-robotics-gbp/mapviz-release;${ROS_BRANCH};protocol=https"
SRCREV = "61c539ae4e033965391e43f0384d9be671b31f43"
S = "${WORKDIR}/git"

ROS_BUILD_TYPE = "ament_cmake"

inherit ros_${ROS_BUILD_TYPE}
